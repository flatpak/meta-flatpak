require ../common/extend-native.inc

DEPENDS += "glib-networking"
