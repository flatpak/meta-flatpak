EXTRA_OECONF += "--without-sendmail"
