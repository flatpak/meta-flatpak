# Fixup util our corresponding patch lands.
EXTRA_OEMAKE += "bindir=${base_sbindir}"
