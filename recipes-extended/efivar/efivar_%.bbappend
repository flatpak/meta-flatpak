SECURITY_CFLAGS = "${SECURITY_NO_PIE_CFLAGS} ${SECURITY_PIC_CFLAGS}"
