OSTREEBASE     = "${FLATPAKBASE}"
OSTREE_TOPDIR  = "${TOPDIR}"
OSTREE_TMPDIR  = "${TMPDIR}"
#OSTREE_REPO   = "${IMGDEPLOYDIR}/${IMAGE_BASENAME}-${BUILD_ID}.ostree"
OSTREE_REPO    = "${TMPDIR}/ostree-test"
OSTREE_DISTRO  = "${DISTRO}"
OSTREE_KERNEL  = "${DEPLOY_DIR_IMAGE}/${KERNEL_IMAGETYPE}"
OSTREE_ARCH    = "${MACHINE}"
OSTREE_SYSROOT = "${IMAGE_ROOTFS}"