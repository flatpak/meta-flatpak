PACKAGE_INSTALL += "initramfs-framework-module-ostree"
